Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Otto-M-Stängd.IFC
Time: 2025-01-13T07:31:29
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 10024
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 10047
In: Default Storey
PredefinedType: ELEMENT; Material: ABS

# IfcBuildingElementProxy: 20028_7982---*6-13-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20032_M6 Flänsmutter (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20049 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 20075_7982---*6-13-mattssons (10)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 20129_7982--*14-19-mattssons (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30210_100 cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30212_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30213_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30217_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30219_100cm
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30221_100cm Otto Becker
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 30236_4cm (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 33322___6_20-mattssons (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40136_100cm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40137
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40138
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40139 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40142 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40143 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40153-1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40153-2
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40672
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40673
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40676 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40677 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40679 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40698_Otto
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 40700
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: ISO 4762 M4 x 16_09122 4 16-mattssons (4)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Otto-Väv_Uppe Becker
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Träskruv (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
